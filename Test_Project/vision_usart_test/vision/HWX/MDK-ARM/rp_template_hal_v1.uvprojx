# Keil uVision project rp_template_hal_v1.uvprojx, settings and files
target rp_template_hal_v1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rp_template_hal_v1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,__CC_ARM,ARM_MATH_CM4,__TARGET_FPU_VFP,__FPU_PRESENT=1U
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Application/DriverLayer;../Application/DeviceLayer/Imu;../Application/DeviceLayer/Motor;../Application/DeviceLayer/Sensor;../Application/DeviceLayer;../Application/ModuleLayer;../Application/TaskLayer;../Application/AlgorithmLayer;../Application/ConfigLayer;../Application/ProtocolLayer;../Drivers/CMSIS/DSP/Include;..\Application\3508;..\Application\DJI_PID;..\Application\REMOTE;..\Application\CHASSIS;..\Application\GIMBAL;..\Application\CAR;..\Application\SHOOT;..\Application\VISION;..\Application\VISION;..\Application\JUDGE
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/Driver
    ../Application/DriverLayer/: drv_io.c drv_can.c drv_tim.c drv_uart.c drv_adda.c drv_haltick.c driver.c
  group Application/Driver/Imu
    ../Application/DeviceLayer/Imu/: soft_iic.c bmi.c bmi2.c bmi2_common.c bmi2_ois.c bmi270.c bmi270_context.c
  group Application/Device
    ../Application/DeviceLayer/Sensor/: rc_sensor.c imu_sensor.c
    ../Application/DeviceLayer/Motor/: chassis_motor.c
    ../Application/DeviceLayer/: device.c
  group Application/Module
    ../Application/ModuleLayer/: chassis.c
    ../Application/CHASSIS/: my_chassis.c Power_Limit.c
  group Application/Task
    ../Application/TaskLayer/: system_task.c monitor_task.c control_task.c send_task.c
  group Application/Algorithm
    ../Application/AlgorithmLayer/: pid.c crc.c kalman.c rp_math.c S_function.c
  group Application/Config
    ../Application/ConfigLayer/: rp_config.c rp_config.h rp_driver_config.h rp_device_config.h rp_user_config.h
  group Application/Protocol
    ../Application/ProtocolLayer/: rc_protocol.c imu_protocol.c can_protocol.c rm_protocol.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dac.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/DSP/Include/: arm_math.h
    ../Drivers/CMSIS/DSP/Source/MatrixFunctions/: arm_mat_init_f32.c arm_mat_add_f32.c arm_mat_sub_f32.c arm_mat_mult_f32.c arm_mat_trans_f32.c arm_mat_inverse_f32.c
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group MOTOR
    ../Application/3508/: 3508_motor.c 2006_motor.c 6020_motor.c
  group DJI_PID
    ../Application/DJI_PID/: dji_pid.c
  group REMOTE
    ../Application/REMOTE/: remote.c
  group GIMBAL
    ../Application/GIMBAL/: my_gimbal.c
  group CAR
    ../Application/CAR/: car.c
  group README
    ../: README.txt
  group SHOOT
    ../Application/SHOOT/: my_shoot.c
  group VISION
    ../Application/VISION/: vision.c
  group JUDGE
    ../Application/JUDGE/: judge_infantrypotocol.c judge_sensor.c slave.c UI.c judge.c
software components: CMSIS:CORE 5.2.0
